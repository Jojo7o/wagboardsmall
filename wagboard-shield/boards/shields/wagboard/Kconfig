## wagboard-shield/boards/shields/wagboard/Kconfig
```kconfig
menu "Wagboard Shield"
    config SHIELD_WAGBOARD
        bool "Wagboard"
        depends on SHIELD
endmenu
```
